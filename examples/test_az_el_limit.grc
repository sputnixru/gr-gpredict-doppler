<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_az_el_limit</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Just needed for scheduling engine timing</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gpredict_azel_limit</key>
<param><key>id</key><value>gpredict_azel_limit_0</value></param>
<param><key>az_max</key><value>20.0</value></param>
<param><key>el_max</key><value>60.0</value></param>
<param><key>az_min</key><value>240.0</value></param>
<param><key>el_min</key><value>10.0</value></param>
</block>
<block>
<key>gpredict_rotor</key>
<param><key>id</key><value>gpredict_rotor_0</value></param>
<param><key>gpredict_port</key><value>4533</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>minEl</key><value>20.0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gpredict_azel_limit_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>state</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gpredict_rotor_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>az_el</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gpredict_rotor_0</source_block_id><sink_block_id>gpredict_azel_limit_0</sink_block_id><source_key>az_el</source_key><sink_key>az_el</sink_key></connection>
</flow_graph>
